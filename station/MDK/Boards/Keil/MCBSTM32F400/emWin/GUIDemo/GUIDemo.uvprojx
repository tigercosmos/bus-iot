# Keil uVision project GUIDemo.uvprojx, settings and files
target MCBSTM32F400 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0-dev4
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GUIDemo
  c flags: Optim=4
  c define: HSE_VALUE=25000000 DATA_IN_ExtSRAM JOYSTICK_ROTATE
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x68000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Joystick 2.0.0, Board Support:Touchscreen 2.0.0, Board Support:emWin LCD 2.0.0, CMSIS Driver:I2C 2.6, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:I2C 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SRAM 1.5.0, Device:Startup 2.6.0, Graphics:CORE 5.36.0, Graphics:Demo:Automotive 5.36.0, Graphics:Demo:BarGraph 5.36.0, Graphics:Demo:Bitmap 5.36.0, Graphics:Demo:ColorBar 5.36.0, Graphics:Demo:Cursor 5.36.0, Graphics:Demo:Fading 5.36.0, Graphics:Demo:Framework 5.36.0, Graphics:Demo:Graph 5.36.0, Graphics:Demo:ListView 5.36.0, Graphics:Demo:RadialMenu 5.36.0, Graphics:Demo:Skinning 5.36.0, Graphics:Demo:Speed 5.36.0, Graphics:Demo:Speedometer 5.36.0, Graphics:Demo:TransparentDialog 5.36.0, Graphics:Demo:Treeview 5.36.0, Graphics:Demo:WashingMachine 5.36.0, Graphics:Display:MCBQVGA_LG 5.36.0, Graphics:Input Device:Joystick 5.36.0, Graphics:Input Device:Touchscreen 5.36.0
