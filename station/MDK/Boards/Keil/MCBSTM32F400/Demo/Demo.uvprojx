# Keil uVision project Demo.uvprojx, settings and files
target STM32F407 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0-dev4
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=4
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Graphics
    ./: Arrows_16bpp_red.c Button_16bpp.c Bulb_16bpp.c
  group Source Files
    ./: Demo.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Board Support:A/D Converter 2.0.0, Board Support:Accelerometer 2.0.0, Board Support:Buttons 2.0.0, Board Support:Camera 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:Gyroscope 2.0.0, Board Support:Joystick 2.0.0, Board Support:LED 2.0.0, Board Support:Touchscreen 2.0.0, CMSIS Driver:I2C 2.4, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:ADC 1.4.0, Device:STM32Cube HAL:Common 1.4.0, Device:STM32Cube HAL:Cortex 1.4.0, Device:STM32Cube HAL:DCMI 1.4.0, Device:STM32Cube HAL:DMA 1.4.0, Device:STM32Cube HAL:GPIO 1.4.0, Device:STM32Cube HAL:I2C 1.4.0, Device:STM32Cube HAL:PWR 1.4.0, Device:STM32Cube HAL:RCC 1.4.0, Device:STM32Cube HAL:SRAM 1.4.0, Device:Startup 2.6.0
