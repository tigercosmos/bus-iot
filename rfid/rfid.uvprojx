# Keil uVision project rfid.uvprojx, settings and files
target rfid (ARM-ADS)
  device: STM32F469NI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.pdsc
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: rfid
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: --gnu -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -DTARGET_STM32F4 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -DDEVICE_PORTINOUT=1 -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DTARGET_STM32F469 -DARM_MATH_CM4 -DTARGET_STM32F469NI --apcs=interwork -DDEVICE_I2C=1 -DDEVICE_PORTIN=1 -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DTARGET_STM32F469xI --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -DMBED_BUILD_TIMESTAMP=1504711302.52 --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED -DTARGET_STM32F469xx -DDEVICE_TRNG=1 -DTARGET_FAMILY_STM32 -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM -DTARGET_DISCO_F469NI
  c include: .; BSP_DISCO_F469NI; BSP_DISCO_F469NI/Drivers; BSP_DISCO_F469NI/Drivers/BSP; BSP_DISCO_F469NI/Drivers/BSP/Components; BSP_DISCO_F469NI/Drivers/BSP/Components/Common; BSP_DISCO_F469NI/Drivers/BSP/Components/cs43l22; BSP_DISCO_F469NI/Drivers/BSP/Components/ft6x06; BSP_DISCO_F469NI/Drivers/BSP/Components/n25q128a; BSP_DISCO_F469NI/Drivers/BSP/Components/otm8009a; BSP_DISCO_F469NI/Drivers/BSP/STM32469I-Discovery; BSP_DISCO_F469NI/Utilities; BSP_DISCO_F469NI/Utilities/Fonts; LCD_DISCO_F469NI; mbed/.; mbed/TARGET_DISCO_F469NI; mbed/TARGET_DISCO_F469NI/TARGET_STM; mbed/TARGET_DISCO_F469NI/TARGET_STM/TARGET_STM32F4; mbed/TARGET_DISCO_F469NI/TARGET_STM/TARGET_STM32F4/TARGET_STM32F469xI; mbed/TARGET_DISCO_F469NI/TARGET_STM/TARGET_STM32F4/TARGET_STM32F469xI/TARGET_DISCO_F469NI; mbed/TARGET_DISCO_F469NI/TARGET_STM/TARGET_STM32F4/TARGET_STM32F469xI/device; mbed/TARGET_DISCO_F469NI/TARGET_STM/TARGET_STM32F4/device; mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M4,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_STD/stm32f469xx.sct
  group BSP_DISCO_F469NI
    BSP_DISCO_F469NI/Drivers/BSP/Components/Common/: audio.h gyro.h io.h lcd.h ts.h
    BSP_DISCO_F469NI/Drivers/BSP/Components/cs43l22/: cs43l22.c cs43l22.h
    BSP_DISCO_F469NI/Utilities/Fonts/: font12.c font16.c font20.c font24.c font8.c fonts.h
    BSP_DISCO_F469NI/Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06.h
    BSP_DISCO_F469NI/Drivers/BSP/Components/n25q128a/: n25q128a.h
    BSP_DISCO_F469NI/Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a.h
    BSP_DISCO_F469NI/Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery.h stm32469i_discovery_eeprom.c stm32469i_discovery_eeprom.h stm32469i_discovery_lcd.c stm32469i_discovery_lcd.h stm32469i_discovery_qspi.c stm32469i_discovery_qspi.h stm32469i_discovery_sd.c stm32469i_discovery_sd.h stm32469i_discovery_sdram.c stm32469i_discovery_sdram.h stm32469i_discovery_ts.c stm32469i_discovery_ts.h
  group LCD_DISCO_F469NI
    LCD_DISCO_F469NI/: LCD_DISCO_F469NI.cpp LCD_DISCO_F469NI.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o analogout_device.o can_api.o flash_api.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_init_pre.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o mbed_sdk_boot.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o serial_device.o sleep.o spi_api.o startup_stm32f469xx.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.o stm32f4xx_hal_cec.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dfsdm.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_mmc.o stm32f4xx_hal_msp_template.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_adc.o stm32f4xx_ll_crc.o stm32f4xx_ll_dac.o stm32f4xx_ll_dma.o stm32f4xx_ll_dma2d.o stm32f4xx_ll_exti.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_gpio.o stm32f4xx_ll_i2c.o stm32f4xx_ll_lptim.o stm32f4xx_ll_pwr.o stm32f4xx_ll_rcc.o stm32f4xx_ll_rng.o stm32f4xx_ll_rtc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_spi.o stm32f4xx_ll_tim.o stm32f4xx_ll_usart.o stm32f4xx_ll_usb.o stm32f4xx_ll_utils.o stm_spi_api.o sys.o system_clock.o system_stm32f4xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o
    mbed/TARGET_DISCO_F469NI/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_DISCO_F469NI/TARGET_STM/TARGET_STM32F4/: can_device.h common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h spi_device.h
    mbed/TARGET_DISCO_F469NI/TARGET_STM/TARGET_STM32F4/TARGET_STM32F469xI/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32f469xx.h stm32f4xx.h system_stm32f4xx.h
    mbed/TARGET_DISCO_F469NI/TARGET_STM/: gpio_object.h mbed_rtx.h nvic_addr.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h serial_api_hal.h stm32_assert.h
    mbed/: mbed.h
    mbed/TARGET_DISCO_F469NI/TARGET_STM/TARGET_STM32F4/TARGET_STM32F469xI/: objects.h
    mbed/TARGET_DISCO_F469NI/TARGET_STM/TARGET_STM32F4/TARGET_STM32F469xI/TARGET_DISCO_F469NI/: PeripheralNames.h PinNames.h
    mbed/TARGET_DISCO_F469NI/TARGET_STM/TARGET_STM32F4/device/: stm32_hal_legacy.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_mmc.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_dac.h stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.h stm32f4xx_ll_exti.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_gpio.h stm32f4xx_ll_i2c.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_lptim.h stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.h stm32f4xx_ll_rng.h stm32f4xx_ll_rtc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_usart.h stm32f4xx_ll_usb.h stm32f4xx_ll_utils.h stm32f4xx_ll_wwdg.h
  group rfid
    ./: main.cpp mbed_config.h MFRC522.cpp MFRC522.h
